<?xml version="1.0" encoding="ISO-8859-1" standalone="no"?>
<workspace>
  <batchBuild>
    <batchDefinition>
      <name>all</name>
      <member>
        <project>smart_washing_machine</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
      <member>
        <project>smart_washing_machine</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_debug</name>
      <member>
        <project>smart_washing_machine</project>
        <configuration>flexspi_nor_debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>flexspi_nor_release</name>
      <member>
        <project>smart_washing_machine</project>
        <configuration>flexspi_nor_release</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
  <project>
    <path>$WS_DIR$/smart_washing_machine.ewp</path>
  </project>
</workspace>
