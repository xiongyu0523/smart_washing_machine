# IAR project aliyundemo.ewp, settings and files
configuration flexspi_nor_debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6B NXP MIMXRT1052xxx6B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; CPU_MIMXRT1052DVL6B; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; WIFI_WICED
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board; source; 43xxx_wifi/WICED/RTOS/FreeRTOS/WWD; 43xxx_wifi/WICED/WWD; 43xxx_wifi/WICED/WWD/include; 43xxx_wifi/WICED/WWD/include/RTOS; 43xxx_wifi/WICED/WWD/include/network; 43xxx_wifi/WICED/WWD/include/platform; 43xxx_wifi/WICED/WWD/internal; 43xxx_wifi/WICED/WWD/internal/bus_protocols; 43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO; 43xxx_wifi/WICED/WWD/internal/chips/4343W; 43xxx_wifi/WICED/network/LwIP/WWD; 43xxx_wifi/WICED/platform; 43xxx_wifi/WICED/platform/MCU; 43xxx_wifi/WICED/platform/MCU/LPC; 43xxx_wifi/WICED/platform/include; 43xxx_wifi/include; 43xxx_wifi/platforms/MURATA_TYPE1DX; CMSIS; amazon-freertos/FreeRTOS/portable; amazon-freertos/include; component/lists; component/serial_manager; component/uart; device; doc; drivers; lwip/port; lwip/port/arch; lwip/src; lwip/src/include; lwip/src/include/compat/posix; lwip/src/include/compat/posix/arpa; lwip/src/include/compat/posix/net; lwip/src/include/compat/posix/sys; lwip/src/include/compat/stdc; lwip/src/include/lwip; lwip/src/include/lwip/apps; lwip/src/include/lwip/priv; lwip/src/include/lwip/prot; lwip/src/include/netif; lwip/src/include/netif/ppp; lwip/src/include/netif/ppp/polarssl; sdmmc/inc; sdmmc/port; src; startup; utilities; xip
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: aliyundemo.out
  ILINK.IlinkConfigDefines: __stack_size__=0x1000; __heap_size__=0x1000
  ILINK.IlinkIcfFile: MIMXRT1052xxxxx_flexspi_nor.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration flexspi_nor_release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; NDEBUG; CPU_MIMXRT1052DVL6B; HIGH_SPEED_SDIO_CLOCK; PRINTF_ADVANCED_ENABLE=1; FSL_RTOS_FREE_RTOS; WIFI_WICED
  AARM.ADefines: NDEBUG; __STARTUP_INITIALIZE_NONCACHEDATA
  group 43xxx_wifi/app
    43xxx_wifi/app/: test_scan.c wlanif_add.c
  group 43xxx_wifi/include
    43xxx_wifi/include/: wiced_resource.h
  group 43xxx_wifi/internal
    43xxx_wifi/internal/: wifi.c
  group 43xxx_wifi/platforms/MURATA_TYPE1DX
    43xxx_wifi/platforms/MURATA_TYPE1DX/: wifi_nvram_image.h
  group 43xxx_wifi/WICED
    43xxx_wifi/WICED/: generated_mac_address.txt
  group 43xxx_wifi/WICED/network/LwIP/WWD
    43xxx_wifi/WICED/network/LwIP/WWD/: wwd_buffer.c wwd_buffer.h wwd_network.c wwd_network.h
  group 43xxx_wifi/WICED/platform
    43xxx_wifi/WICED/platform/: platform_toolchain.h
  group 43xxx_wifi/WICED/platform/include
    43xxx_wifi/WICED/platform/include/: platform_cache_def.h platform_peripheral.h
  group 43xxx_wifi/WICED/platform/MCU
    43xxx_wifi/WICED/platform/MCU/: wwd_platform_common.h wwd_platform_separate_mcu.c wwd_resources.c
  group 43xxx_wifi/WICED/platform/MCU/LPC
    43xxx_wifi/WICED/platform/MCU/LPC/: platform_mcu_peripheral.h
  group 43xxx_wifi/WICED/platform/MCU/LPC/WWD
    43xxx_wifi/WICED/platform/MCU/LPC/WWD/: wwd_platform.c wwd_SDIO.c
  group 43xxx_wifi/WICED/RTOS/FreeRTOS/WWD
    43xxx_wifi/WICED/RTOS/FreeRTOS/WWD/: wwd_FreeRTOS_systick.h wwd_rtos.c wwd_rtos.h
  group 43xxx_wifi/WICED/WWD
    43xxx_wifi/WICED/WWD/: wwd.h wwd_wiced.h
  group 43xxx_wifi/WICED/WWD/include
    43xxx_wifi/WICED/WWD/include/: wwd_assert.h wwd_constants.h wwd_debug.h wwd_eapol.h wwd_events.h wwd_management.h wwd_poll.h wwd_structures.h wwd_wifi.h wwd_wifi_sleep.h wwd_wlioctl.h
  group 43xxx_wifi/WICED/WWD/include/network
    43xxx_wifi/WICED/WWD/include/network/: wwd_buffer_interface.h wwd_network_constants.h wwd_network_interface.h
  group 43xxx_wifi/WICED/WWD/include/platform
    43xxx_wifi/WICED/WWD/include/platform/: wwd_bus_interface.h wwd_platform_interface.h wwd_resource_interface.h wwd_sdio_interface.h wwd_spi_interface.h
  group 43xxx_wifi/WICED/WWD/include/RTOS
    43xxx_wifi/WICED/WWD/include/RTOS/: wwd_rtos_interface.h
  group 43xxx_wifi/WICED/WWD/internal
    43xxx_wifi/WICED/WWD/internal/: tlv.c tlv.h wwd_ap.h wwd_ap_common.c wwd_ap_common.h wwd_bcmendian.h wwd_clm.c wwd_clm.h wwd_debug.c wwd_eapol.c wwd_internal.c wwd_internal.h wwd_logging.h wwd_management.c wwd_rtos_interface.c wwd_sdpcm.c wwd_sdpcm.h wwd_thread.c wwd_thread.h wwd_thread_internal.c wwd_thread_internal.h wwd_wifi.c wwd_wifi_chip_common.c wwd_wifi_chip_common.h wwd_wifi_sleep.c
  group 43xxx_wifi/WICED/WWD/internal/bus_protocols
    43xxx_wifi/WICED/WWD/internal/bus_protocols/: wwd_bus_common.c wwd_bus_protocol_interface.h
  group 43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO
    43xxx_wifi/WICED/WWD/internal/bus_protocols/SDIO/: wwd_bus_protocol.c wwd_bus_protocol.h
  group 43xxx_wifi/WICED/WWD/internal/chips/4343W
    43xxx_wifi/WICED/WWD/internal/chips/4343W/: 4343WA1.h 4343WA1_clm.h 4343WA1_clm_mfg.h 4343WA1_mfg.h chip_constants.h resources.c resources.h wwd_ap.c wwd_chip_specific_functions.c
  group amazon-freertos/FreeRTOS
    amazon-freertos/FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group amazon-freertos/FreeRTOS/portable
    amazon-freertos/FreeRTOS/portable/: fsl_tickless_generic.h fsl_tickless_systick.c heap_4.c port.c portasm.s portmacro.h readme.txt
  group amazon-freertos/include
    amazon-freertos/include/: deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h stream_buffer.h task.h threading_alt.h timers.h
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm7.h mpu_armv7.h mpu_armv8.h
  group component/lists
    component/lists/: generic_list.c generic_list.h
  group component/serial_manager
    component/serial_manager/: serial_manager.c serial_manager.h serial_port_uart.c serial_port_uart.h
  group component/uart
    component/uart/: lpuart_adapter.c uart.h
  group device
    device/: fsl_device_registers.h MIMXRT1052.h MIMXRT1052_features.h system_MIMXRT1052.c system_MIMXRT1052.h
  group doc
    doc/: readme.txt
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_gpio.c fsl_gpio.h fsl_iomuxc.h fsl_lpuart.c fsl_lpuart.h fsl_usdhc.c fsl_usdhc.h
  group lwip
    lwip/: CHANGELOG ChangeLogKSDK.txt CMakeLists.txt COPYING FEATURES FILES README UPGRADING
  group lwip/doc
    lwip/doc/: contrib.txt FILES mdns.txt mqtt_client.txt NO_SYS_SampleCode.c ppp.txt savannah.txt ZeroCopyRx.c
  group lwip/doc/doxygen
    lwip/doc/doxygen/: generate.bat generate.sh lwip.Doxyfile lwip.Doxyfile.cmake.in main_page.h
  group lwip/doc/doxygen/output
    lwip/doc/doxygen/output/: index.html
  group lwip/port
    lwip/port/: sys_arch.c
  group lwip/port/arch
    lwip/port/arch/: cc.h perf.h sys_arch.h
  group lwip/src
    lwip/src/: FILES
  group lwip/src/api
    lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwip/src/apps/lwiperf
    lwip/src/apps/lwiperf/: lwiperf.c
  group lwip/src/core
    lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
  group lwip/src/core/ipv4
    lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group lwip/src/core/ipv6
    lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
  group lwip/src/include/compat/posix
    lwip/src/include/compat/posix/: netdb.h
  group lwip/src/include/compat/posix/arpa
    lwip/src/include/compat/posix/arpa/: inet.h
  group lwip/src/include/compat/posix/net
    lwip/src/include/compat/posix/net/: if.h
  group lwip/src/include/compat/posix/sys
    lwip/src/include/compat/posix/sys/: socket.h
  group lwip/src/include/compat/stdc
    lwip/src/include/compat/stdc/: errno.h
  group lwip/src/include/lwip
    lwip/src/include/lwip/: altcp.h altcp_tcp.h altcp_tls.h api.h arch.h autoip.h debug.h def.h dhcp.h dhcp6.h dns.h err.h errno.h etharp.h ethip6.h icmp.h icmp6.h if_api.h igmp.h inet.h inet_chksum.h init.h ip.h ip4.h ip4_addr.h ip4_frag.h ip6.h ip6_addr.h ip6_frag.h ip6_zone.h ip_addr.h mem.h memp.h mld6.h nd6.h netbuf.h netdb.h netif.h netifapi.h opt.h pbuf.h raw.h sio.h snmp.h sockets.h stats.h sys.h tcp.h tcpbase.h tcpip.h timeouts.h udp.h
  group lwip/src/include/lwip/apps
    lwip/src/include/lwip/apps/: lwiperf.h
  group lwip/src/include/lwip/priv
    lwip/src/include/lwip/priv/: altcp_priv.h api_msg.h mem_priv.h memp_priv.h memp_std.h nd6_priv.h raw_priv.h sockets_priv.h tcp_priv.h tcpip_priv.h
  group lwip/src/include/lwip/prot
    lwip/src/include/lwip/prot/: autoip.h dhcp.h dhcp6.h dns.h etharp.h ethernet.h iana.h icmp.h icmp6.h ieee.h igmp.h ip.h ip4.h ip6.h mld6.h nd6.h tcp.h udp.h
  group lwip/src/include/netif
    lwip/src/include/netif/: bridgeif.h bridgeif_opts.h etharp.h ethernet.h ieee802154.h lowpan6.h lowpan6_ble.h lowpan6_common.h lowpan6_opts.h slipif.h zepif.h
  group lwip/src/include/netif/ppp
    lwip/src/include/netif/ppp/: ccp.h chap-md5.h chap-new.h chap_ms.h eap.h ecp.h eui64.h fsm.h ipcp.h ipv6cp.h lcp.h magic.h mppe.h ppp.h ppp_impl.h ppp_opts.h pppapi.h pppcrypt.h pppdebug.h pppoe.h pppol2tp.h pppos.h upap.h vj.h
  group lwip/src/include/netif/ppp/polarssl
    lwip/src/include/netif/ppp/polarssl/: arc4.h des.h md4.h md5.h sha1.h
  group lwip/src/netif
    lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c FILES lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lwip/src/netif/ppp
    lwip/src/netif/ppp/: auth.c ccp.c chap-md5.c chap-new.c chap_ms.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c lwip_ecp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c PPPD_FOLLOWUP pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c
  group lwip/src/netif/ppp/polarssl
    lwip/src/netif/ppp/polarssl/: arc4.c des.c md4.c md5.c README sha1.c
  group sdmmc/inc
    sdmmc/inc/: fsl_sdio.h fsl_sdmmc_common.h fsl_sdmmc_host.h fsl_sdmmc_spec.h
  group sdmmc/port
    sdmmc/port/: fsl_sdmmc_event.c fsl_sdmmc_event.h fsl_sdmmc_host.c
  group sdmmc/src
    sdmmc/src/: fsl_sdio.c fsl_sdmmc_common.c
  group source
    source/: FreeRTOSConfig.h lwipopts.h wiced_iperf.c
  group src
    src/: evkbimxrt1050.mac MIMXRT1052xxxxx_ram.icf
  group startup
    startup/: startup_MIMXRT1052.s
  group utilities
    utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_str.c fsl_str.h
  group xip
    xip/: evkbimxrt1050_flexspi_nor_config.c evkbimxrt1050_flexspi_nor_config.h evkbimxrt1050_sdram_ini_dcd.c evkbimxrt1050_sdram_ini_dcd.h fsl_flexspi_nor_boot.c fsl_flexspi_nor_boot.h
